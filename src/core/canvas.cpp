#include "canvas.h"

// 5x7 bitmap font (ASCII 32-126)
static const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, // space
    {0x00,0x00,0x5F,0x00,0x00}, // !
    {0x00,0x07,0x00,0x07,0x00}, // "
    {0x14,0x7F,0x14,0x7F,0x14}, // #
    {0x24,0x2A,0x7F,0x2A,0x12}, // $
    {0x23,0x13,0x08,0x64,0x62}, // %
    {0x36,0x49,0x55,0x22,0x50}, // &
    {0x00,0x05,0x03,0x00,0x00}, // '
    {0x00,0x1C,0x22,0x41,0x00}, // (
    {0x00,0x41,0x22,0x1C,0x00}, // )
    {0x08,0x2A,0x1C,0x2A,0x08}, // *
    {0x08,0x08,0x3E,0x08,0x08}, // +
    {0x00,0x50,0x30,0x00,0x00}, // ,
    {0x08,0x08,0x08,0x08,0x08}, // -
    {0x00,0x60,0x60,0x00,0x00}, // .
    {0x20,0x10,0x08,0x04,0x02}, // /
    {0x3E,0x51,0x49,0x45,0x3E}, // 0
    {0x00,0x42,0x7F,0x40,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46}, // 2
    {0x21,0x41,0x45,0x4B,0x31}, // 3
    {0x18,0x14,0x12,0x7F,0x10}, // 4
    {0x27,0x45,0x45,0x45,0x39}, // 5
    {0x3C,0x4A,0x49,0x49,0x30}, // 6
    {0x01,0x71,0x09,0x05,0x03}, // 7
    {0x36,0x49,0x49,0x49,0x36}, // 8
    {0x06,0x49,0x49,0x29,0x1E}, // 9
    {0x00,0x36,0x36,0x00,0x00}, // :
    {0x00,0x56,0x36,0x00,0x00}, // ;
    {0x00,0x08,0x14,0x22,0x41}, // <
    {0x14,0x14,0x14,0x14,0x14}, // =
    {0x41,0x22,0x14,0x08,0x00}, // >
    {0x02,0x01,0x51,0x09,0x06}, // ?
    {0x32,0x49,0x79,0x41,0x3E}, // @
    {0x7E,0x11,0x11,0x11,0x7E}, // A
    {0x7F,0x49,0x49,0x49,0x36}, // B
    {0x3E,0x41,0x41,0x41,0x22}, // C
    {0x7F,0x41,0x41,0x22,0x1C}, // D
    {0x7F,0x49,0x49,0x49,0x41}, // E
    {0x7F,0x09,0x09,0x01,0x01}, // F
    {0x3E,0x41,0x41,0x51,0x32}, // G
    {0x7F,0x08,0x08,0x08,0x7F}, // H
    {0x00,0x41,0x7F,0x41,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01}, // J
    {0x7F,0x08,0x14,0x22,0x41}, // K
    {0x7F,0x40,0x40,0x40,0x40}, // L
    {0x7F,0x02,0x04,0x02,0x7F}, // M
    {0x7F,0x04,0x08,0x10,0x7F}, // N
    {0x3E,0x41,0x41,0x41,0x3E}, // O
    {0x7F,0x09,0x09,0x09,0x06}, // P
    {0x3E,0x41,0x51,0x21,0x5E}, // Q
    {0x7F,0x09,0x19,0x29,0x46}, // R
    {0x46,0x49,0x49,0x49,0x31}, // S
    {0x01,0x01,0x7F,0x01,0x01}, // T
    {0x3F,0x40,0x40,0x40,0x3F}, // U
    {0x1F,0x20,0x40,0x20,0x1F}, // V
    {0x7F,0x20,0x18,0x20,0x7F}, // W
    {0x63,0x14,0x08,0x14,0x63}, // X
    {0x03,0x04,0x78,0x04,0x03}, // Y
    {0x61,0x51,0x49,0x45,0x43}, // Z
    {0x00,0x00,0x7F,0x41,0x41}, // [
    {0x02,0x04,0x08,0x10,0x20}, // backslash
    {0x41,0x41,0x7F,0x00,0x00}, // ]
    {0x04,0x02,0x01,0x02,0x04}, // ^
    {0x40,0x40,0x40,0x40,0x40}, // _
    {0x00,0x01,0x02,0x04,0x00}, // `
    {0x20,0x54,0x54,0x54,0x78}, // a
    {0x7F,0x48,0x44,0x44,0x38}, // b
    {0x38,0x44,0x44,0x44,0x20}, // c
    {0x38,0x44,0x44,0x48,0x7F}, // d
    {0x38,0x54,0x54,0x54,0x18}, // e
    {0x08,0x7E,0x09,0x01,0x02}, // f
    {0x08,0x14,0x54,0x54,0x3C}, // g
    {0x7F,0x08,0x04,0x04,0x78}, // h
    {0x00,0x44,0x7D,0x40,0x00}, // i
    {0x20,0x40,0x44,0x3D,0x00}, // j
    {0x00,0x7F,0x10,0x28,0x44}, // k
    {0x00,0x41,0x7F,0x40,0x00}, // l
    {0x7C,0x04,0x18,0x04,0x78}, // m
    {0x7C,0x08,0x04,0x04,0x78}, // n
    {0x38,0x44,0x44,0x44,0x38}, // o
    {0x7C,0x14,0x14,0x14,0x08}, // p
    {0x08,0x14,0x14,0x18,0x7C}, // q
    {0x7C,0x08,0x04,0x04,0x08}, // r
    {0x48,0x54,0x54,0x54,0x20}, // s
    {0x04,0x3F,0x44,0x40,0x20}, // t
    {0x3C,0x40,0x40,0x20,0x7C}, // u
    {0x1C,0x20,0x40,0x20,0x1C}, // v
    {0x3C,0x40,0x30,0x40,0x3C}, // w
    {0x44,0x28,0x10,0x28,0x44}, // x
    {0x0C,0x50,0x50,0x50,0x3C}, // y
    {0x44,0x64,0x54,0x4C,0x44}, // z
    {0x00,0x08,0x36,0x41,0x00}, // {
    {0x00,0x00,0x7F,0x00,0x00}, // |
    {0x00,0x41,0x36,0x08,0x00}, // }
    {0x08,0x08,0x2A,0x1C,0x08}, // ~
};

// Extended glyphs for UTF-8 characters (5x7 bitmaps)
struct ExtGlyph { uint32_t codepoint; uint8_t bitmap[5]; };

static const ExtGlyph extGlyphs[] = {
    // ╯ U+256F - arc up-left (arm raising)
    {0x256F, {0x20,0x10,0x08,0x04,0x03}},
    // ° U+00B0 - degree sign
    {0x00B0, {0x00,0x06,0x09,0x06,0x00}},
    // □ U+25A1 - white square
    {0x25A1, {0x7F,0x41,0x41,0x41,0x7F}},
    // ︵ U+FE35 - arc (throwing motion)
    {0xFE35, {0x10,0x28,0x44,0x28,0x10}},
    // ♪ U+266A - eighth note
    {0x266A, {0x60,0x70,0x3F,0x02,0x04}},
    // ♫ U+266B - beamed notes left half (col4 has beam to bridge 1px gap)
    {0x266B, {0x30,0x38,0x1F,0x01,0x01}},
    // ♬ U+266C - beamed notes right half
    {0x266C, {0x62,0x72,0x3E,0x00,0x00}},
    // ノ U+30CE - katakana no (arm reaching)
    {0x30CE, {0x20,0x10,0x08,0x04,0x02}},
    // ┏ U+250F - top-left heavy corner (arm up-left)
    {0x250F, {0x00,0x00,0x1F,0x10,0x10}},
    // ┛ U+251B - bottom-right heavy corner (leg down-right)
    {0x251B, {0x04,0x04,0x7C,0x00,0x00}},
    // ┗ U+2517 - bottom-left heavy corner (leg down-left)
    {0x2517, {0x00,0x00,0x7C,0x04,0x04}},
    // ┓ U+2513 - top-right heavy corner (arm up-right)
    {0x2513, {0x10,0x10,0x1F,0x00,0x00}},
};
static const int EXT_GLYPH_COUNT = 12;

static const uint8_t* findExtGlyph(uint32_t cp) {
    for (int i = 0; i < EXT_GLYPH_COUNT; i++) {
        if (extGlyphs[i].codepoint == cp) return extGlyphs[i].bitmap;
    }
    return nullptr;
}

static int utf8Decode(const char* s, uint32_t& cp) {
    uint8_t b = (uint8_t)s[0];
    if (b < 0x80) { cp = b; return 1; }
    if ((b & 0xE0) == 0xC0) { cp = (b & 0x1F) << 6 | (s[1] & 0x3F); return 2; }
    if ((b & 0xF0) == 0xE0) { cp = (b & 0x0F) << 12 | (s[1] & 0x3F) << 6 | (s[2] & 0x3F); return 3; }
    if ((b & 0xF8) == 0xF0) { cp = (b & 0x07) << 18 | (s[1] & 0x3F) << 12 | (s[2] & 0x3F) << 6 | (s[3] & 0x3F); return 4; }
    cp = '?'; return 1;
}

static int utf8CharCount(const char* str) {
    int count = 0;
    while (*str) {
        uint32_t cp;
        str += utf8Decode(str, cp);
        count++;
    }
    return count;
}

void Canvas::drawString(const char* str, int x, int y) {
    if (!str) return;

    int len = utf8CharCount(str);
    int charW = (int)(6 * _textSize);
    int totalW = len * charW;

    int startX = x;
    if (_textDatum == top_center) startX = x - totalW / 2;
    else if (_textDatum == top_right) startX = x - totalW;

    const char* p = str;
    int i = 0;
    while (*p) {
        uint32_t cp;
        p += utf8Decode(p, cp);

        const uint8_t* glyph = nullptr;
        if (cp >= 32 && cp <= 126) {
            glyph = font5x7[cp - 32];
        } else {
            glyph = findExtGlyph(cp);
            if (!glyph) glyph = font5x7['?' - 32];
        }

        int cx = startX + i * charW;

        for (int col = 0; col < 5; col++) {
            uint8_t line = glyph[col];
            for (int row = 0; row < 7; row++) {
                if (line & (1 << row)) {
                    if (_textSize <= 1.0f) {
                        drawPixel(cx + col, y + row, _textColor);
                    } else {
                        int sw = (int)_textSize;
                        int sh = (int)_textSize;
                        fillRect(cx + col * sw, y + row * sh, sw, sh, _textColor);
                    }
                }
            }
        }
        if (cp == 0x266B) {
            if (_textSize <= 1.0f) {
                drawPixel(cx + 5, y, _textColor);
            } else {
                int sw = (int)_textSize;
                int sh = (int)_textSize;
                fillRect(cx + 5 * sw, y, sw, sh, _textColor);
            }
        }
        i++;
    }
}
